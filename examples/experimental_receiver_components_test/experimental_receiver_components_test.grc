options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: experimental_receiver_components_test
    output_language: python
    run_options: run
    title: Experimental receiver components test
  states: {}

blocks:
- name: fc
  id: variable_qtgui_range
  parameters:
    label: fc
    start: 900e6
    step: 200e3
    stop: 1000e6
    value: 938.4e6
  states: {}
- name: g
  id: variable_qtgui_range
  parameters:
    label: g
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: ppm
  id: variable_qtgui_range
  parameters:
    label: ppm
    start: '-50'
    step: '0.1'
    stop: '50'
    value: '-4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6/100
  states: {}
- name: samp_rate2
  id: variable
  parameters:
    value: 13e6/12
  states: {}
- name: OSR
  id: parameter
  parameters:
    label: Over Sampling Ratio
    type: intx
    value: '4'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: gsm_fcch_detector_0
  id: gsm_fcch_detector
  parameters:
    OSR: OSR
  states: {}
- name: gsm_sch_detector_0
  id: gsm_sch_detector
  parameters:
    OSR: OSR
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 200e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: samp_rate/samp_rate2
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    name: QT GUI Plot
    nconnections: '2'
    size: int(51*4*8*156.25)
    srate: samp_rate2
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"fcch"'
    type: float
    update_time: (51.0*4*8*156.25)/samp_rate
    ymax: '2'
    ymin: '-0.00001'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    bw0: 250e3
    corr0: ppm
    freq0: fc
    gain0: g
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_0, '1']
- [gsm_fcch_detector_0, '0', blocks_complex_to_mag_0_0, '0']
- [gsm_fcch_detector_0, '0', gsm_sch_detector_0, '0']
- [gsm_sch_detector_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', gsm_fcch_detector_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
