options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: tch_f_reception
    output_language: python
    run_options: run
  states: {}

blocks:
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '8000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out.gsm
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: input_file_name
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767.0'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '33'
    type: byte
  states: {}
- name: fc
  id: parameter
  parameters:
    label: fc
    short_id: f
    type: eng_float
    value: 937e6
  states: {}
- name: gsm_clock_offset_control_0
  id: gsm_clock_offset_control
  parameters:
    fc: fc
    osr: osr
    samp_rate: samp_rate
  states: {}
- name: gsm_control_channels_decoder_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_decryption_0_0_0
  id: gsm_decryption
  parameters:
    a5_version: '1'
    k_c: '[0x1e, 0xf0, 0x0b, 0xab, 0x3b, 0xac, 0x70, 0x02]'
  states: {}
- name: gsm_decryption_0_0_0_0
  id: gsm_decryption
  parameters:
    a5_version: '1'
    k_c: '[0x1e, 0xf0, 0x0b, 0xab, 0x3b, 0xac, 0x70, 0x02]'
  states: {}
- name: gsm_input_0
  id: gsm_input
  parameters:
    ppm: '0'
    samp_rate_in: samp_rate
  states: {}
- name: gsm_message_printer_0
  id: gsm_message_printer
  parameters:
    prepend_fnr: 'False'
    prepend_frame_count: 'False'
    prepend_string: '""'
    print_gsmtap_header: 'False'
  states: {}
- name: gsm_message_printer_0_1
  id: gsm_message_printer
  parameters:
    prepend_fnr: 'False'
    prepend_frame_count: 'False'
    prepend_string: '""'
    print_gsmtap_header: 'False'
  states: {}
- name: gsm_receiver_0
  id: gsm_receiver
  parameters:
    osr: osr
  states: {}
- name: gsm_tch_f_chans_demapper_0
  id: gsm_tch_f_chans_demapper
  parameters:
    timeslot_nr: '5'
  states: {}
- name: gsm_tch_f_decoder_0
  id: gsm_tch_f_decoder
  parameters:
    boundary_check: 'True'
    mode: gsm.TCH_FS
  states: {}
- name: input_file_name
  id: parameter
  parameters:
    label: input_file_name
    short_id: i
    type: str
    value: '"vf_call6_a725_d174_g5_Kc1EF00BAB3BAC7002.cfile"'
  states: {}
- name: osr
  id: parameter
  parameters:
    label: OSR
    type: intx
    value: '4'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    short_id: s
    type: eng_float
    value: 100.0e6/174.0
  states: {}
- name: vocoder_gsm_fr_decode_ps_0
  id: vocoder_gsm_fr_decode_ps
  parameters: {}
  states: {}

connections:
- [blocks_file_source_0, '0', gsm_input_0, '0']
- [blocks_short_to_float_0, '0', audio_sink_0, '0']
- [blocks_stream_to_vector_0, '0', vocoder_gsm_fr_decode_ps_0, '0']
- [gsm_clock_offset_control_0, ctrl, gsm_input_0, ctrl_in]
- [gsm_control_channels_decoder_0, msgs, gsm_message_printer_0, msgs]
- [gsm_decryption_0_0_0, bursts, gsm_tch_f_decoder_0, bursts]
- [gsm_decryption_0_0_0_0, bursts, gsm_control_channels_decoder_0, bursts]
- [gsm_input_0, '0', gsm_receiver_0, '0']
- [gsm_receiver_0, C0, gsm_tch_f_chans_demapper_0, bursts]
- [gsm_receiver_0, measurements, gsm_clock_offset_control_0, measurements]
- [gsm_tch_f_chans_demapper_0, acch_bursts, gsm_decryption_0_0_0_0, bursts]
- [gsm_tch_f_chans_demapper_0, tch_bursts, gsm_decryption_0_0_0, bursts]
- [gsm_tch_f_decoder_0, msgs, gsm_message_printer_0_1, msgs]
- [gsm_tch_f_decoder_0, voice, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_stream_to_vector_0, '0']
- [vocoder_gsm_fr_decode_ps_0, '0', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
