<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_rtl_taggery_pythonowe</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate2</value></param>
<param><key>value</key><value>13e6/12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100e6/100</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>OSR</value></param>
<param><key>label</key><value>Over Sampling Ratio</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ppm</value></param>
<param><key>label</key><value>ppm</value></param>
<param><key>value</key><value>-4</value></param>
<param><key>start</key><value>-50</value></param>
<param><key>stop</key><value>50</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>g</value></param>
<param><key>label</key><value>g</value></param>
<param><key>value</key><value>20</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value>fc</value></param>
<param><key>value</key><value>938.4e6</value></param>
<param><key>start</key><value>900e6</value></param>
<param><key>stop</key><value>1000e6</value></param>
<param><key>step</key><value>200e3</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>fractional_resampler_xx</key>
<param><key>id</key><value>fractional_resampler_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>resamp_ratio</key><value>samp_rate/samp_rate2</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>200e3</value></param>
<param><key>width</key><value>10e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
</block>
<block>
<key>gsm_fcch_detector</key>
<param><key>id</key><value>gsm_fcch_detector_0</value></param>
<param><key>OSR</key><value>OSR</value></param>
</block>
<block>
<key>gsm_sch_detector</key>
<param><key>id</key><value>gsm_sch_detector_0</value></param>
<param><key>OSR</key><value>OSR</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>int(51*4*8*156.25)</value></param>
<param><key>srate</key><value>samp_rate2</value></param>
<param><key>ymin</key><value>-0.00001</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>update_time</key><value>(51.0*4*8*156.25)/samp_rate</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"fcch"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>fc</value></param>
<param><key>corr0</key><value>ppm</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>g</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>250e3</value></param>
</block>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0</source_block_id><sink_block_id>gsm_fcch_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>fractional_resampler_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_fcch_detector_0</source_block_id><sink_block_id>gsm_sch_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_fcch_detector_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gsm_sch_detector_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
