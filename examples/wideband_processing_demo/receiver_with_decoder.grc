options:
  parameters:
    author: Piotr Krysik
    category: Custom
    generate_options: hb
    id: receiver_with_decoder
    output_language: python
    run_options: run
    title: Receiver With Decoder
  states: {}

blocks:
- name: samp_rate_out
  id: variable
  parameters:
    value: 1625000.0/6.0*OSR
  states: {}
- name: OSR
  id: parameter
  parameters:
    label: OSR
    type: intx
    value: '4'
  states: {}
- name: bursts
  id: pad_sink
  parameters:
    label: bursts
    optional: 'True'
    type: message
  states: {}
- name: chan_num
  id: parameter
  parameters:
    label: Channel number
    type: intx
    value: '0'
  states: {}
- name: fc
  id: parameter
  parameters:
    label: fc
    short_id: p
    type: eng_float
    value: 939.4e6
  states: {}
- name: gsm_bcch_ccch_demapper_0
  id: gsm_bcch_ccch_demapper
  parameters:
    timeslot_nr: '0'
  states: {}
- name: gsm_clock_offset_control_0
  id: gsm_clock_offset_control
  parameters:
    fc: fc
    osr: OSR
    samp_rate: samp_rate
  states: {}
- name: gsm_control_channels_decoder_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_input_0
  id: gsm_input
  parameters:
    osr: OSR
    samp_rate_in: samp_rate
  states: {}
- name: gsm_receiver_0
  id: gsm_receiver
  parameters:
    cell_allocation: '[chan_num]'
    osr: OSR
  states: {}
- name: in_0
  id: pad_source
  parameters:
    label: in
    optional: 'True'
    type: complex
  states: {}
- name: msgs
  id: pad_sink
  parameters:
    label: msgs
    optional: 'True'
    type: message
  states: {}
- name: ppm
  id: parameter
  parameters:
    label: ppm
    short_id: p
    type: eng_float
    value: '0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    short_id: s
    type: eng_float
    value: 0.2e6
  states: {}

connections:
- [gsm_bcch_ccch_demapper_0, bursts, bursts, in]
- [gsm_bcch_ccch_demapper_0, bursts, gsm_control_channels_decoder_0, bursts]
- [gsm_clock_offset_control_0, ctrl, gsm_input_0, ctrl_in]
- [gsm_control_channels_decoder_0, msgs, msgs, in]
- [gsm_input_0, '0', gsm_receiver_0, '0']
- [gsm_receiver_0, C0, gsm_bcch_ccch_demapper_0, bursts]
- [gsm_receiver_0, measurements, gsm_clock_offset_control_0, measurements]
- [in_0, '0', gsm_input_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
