options:
  parameters:
    author: Piotr Krysik
    category: Custom
    description: Demonstration of uplink decoding using data captured with use of Multi-rtl
    generate_options: no_gui
    id: uplink_decoding_multi_rtl
    output_language: python
    run_options: run
    title: Uplink decoding demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: sms_multirtl_downlink_tail.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: sms_multirtl_uplink_tail.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_socket_pdu_0_0_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4729'
    type: UDP_CLIENT
  states: {}
- name: gsm_clock_offset_control_0
  id: gsm_clock_offset_control
  parameters:
    fc: 947.8e6
    osr: osr
    samp_rate: samp_rate
  states: {}
- name: gsm_control_channels_decoder_0_1
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_1_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_decryption_0_3
  id: gsm_decryption
  parameters:
    a5_version: '1'
    k_c: '[0x46,0x77,0x2d,0x54,0xa3,0xa3,0xc3,0x1c]'
  states: {}
- name: gsm_input_0
  id: gsm_input
  parameters:
    fc: 947.8e6
    osr: '4'
    ppm: '0'
    samp_rate_in: samp_rate
  states: {}
- name: gsm_input_0_0
  id: gsm_input
  parameters:
    fc: 947.8e6-45e6
    osr: '4'
    ppm: '0'
    samp_rate_in: samp_rate
  states: {}
- name: gsm_message_printer_0_0
  id: gsm_message_printer
  parameters:
    prepend_fnr: 'False'
    prepend_frame_count: 'False'
    prepend_string: '""'
    print_gsmtap_header: 'False'
  states: {}
- name: gsm_receiver_with_uplink_0
  id: gsm_receiver_with_uplink
  parameters:
    cell_allocation: '[22]'
    comment: |-
      arfcn: 22
      Training Sequence: 2
    osr: '4'
    tseq_nums: '[2]'
  states: {}
- name: gsm_sdcch8_demapper_0
  id: gsm_sdcch8_demapper
  parameters:
    timeslot_nr: '1'
  states: {}
- name: osr
  id: parameter
  parameters:
    label: OSR
    type: intx
    value: '4'
  states: {}
- name: socket_pdu_server
  id: network_socket_pdu
  parameters:
    comment: added in order to avoid generating ICMP messages
    host: 127.0.0.1
    mtu: '10000'
    port: '4729'
    type: UDP_SERVER
  states: {}

connections:
- [blocks_file_source_0, '0', gsm_input_0, '0']
- [blocks_file_source_0_0, '0', gsm_input_0_0, '0']
- [gsm_clock_offset_control_0, ctrl, gsm_input_0, ctrl_in]
- [gsm_clock_offset_control_0, ctrl, gsm_input_0_0, ctrl_in]
- [gsm_control_channels_decoder_0_1, msgs, blocks_socket_pdu_0_0_0, pdus]
- [gsm_control_channels_decoder_0_1, msgs, gsm_message_printer_0_0, msgs]
- [gsm_control_channels_decoder_0_1_0, msgs, blocks_socket_pdu_0_0_0, pdus]
- [gsm_control_channels_decoder_0_1_0, msgs, gsm_message_printer_0_0, msgs]
- [gsm_decryption_0_3, bursts, gsm_control_channels_decoder_0_1_0, bursts]
- [gsm_input_0, '0', gsm_receiver_with_uplink_0, '0']
- [gsm_input_0_0, '0', gsm_receiver_with_uplink_0, '1']
- [gsm_receiver_with_uplink_0, C0, gsm_sdcch8_demapper_0, bursts]
- [gsm_receiver_with_uplink_0, measurements, gsm_clock_offset_control_0, measurements]
- [gsm_sdcch8_demapper_0, bursts, gsm_control_channels_decoder_0_1, bursts]
- [gsm_sdcch8_demapper_0, bursts, gsm_decryption_0_3, bursts]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
