<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>grgsm_tmsi_dumper</value></param>
<param><key>author</key><value>Chris Becker</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Monitoring and dump tmsi.</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>Gr-gsm TMSI Dumper</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>args</value></param>
<param><key>label</key><value>Device Arguments</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"rtl0"</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>int(rec_len*samp_rate)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_cc_0</value></param>
<param><key>phase_inc</key><value>-2*pi*shiftoff/samp_rate</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>serverport</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_1</value></param>
<param><key>host</key><value>collector</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>port</key><value>collectorport</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>collector</value></param>
<param><key>label</key><value>IP or DNS name of collector point</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>localhost</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>collectorport</value></param>
<param><key>label</key><value>UDP port number of collector</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>4729</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fc</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>GSM channel's central frequency</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>930.2e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fc</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>GSM channel's central frequency</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>932.8e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fc</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>GSM channel's central frequency</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>935.8e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value>GSM channel's central frequency</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>952.2e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>short_id</key><value>g</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>gsm_bcch_ccch_sdcch4_demapper</key>
<param><key>id</key><value>gsm_bcch_ccch_sdcch4_demapper_0</value></param>
<param><key>timeslot_nr</key><value>0</value></param>
</block>
<block>
<key>gsm_clock_offset_control</key>
<param><key>id</key><value>gsm_clock_offset_control_0</value></param>
<param><key>osr</key><value>osr</value></param>
<param><key>fc</key><value>fc-shiftoff</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0_0</value></param>
</block>
<block>
<key>gsm_decryption</key>
<param><key>id</key><value>gsm_decryption_0</value></param>
<param><key>a5_version</key><value>1</value></param>
<param><key>k_c</key><value>[]</value></param>
</block>
<block>
<key>gsm_input</key>
<param><key>id</key><value>gsm_input_0</value></param>
<param><key>osr</key><value>4</value></param>
<param><key>ppm</key><value>ppm-int(ppm)</value></param>
<param><key>samp_rate_in</key><value>samp_rate</value></param>
</block>
<block>
<key>gsm_message_printer</key>
<param><key>id</key><value>gsm_message_printer_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>prepend_frame_count</key><value>False</value></param>
<param><key>prepend_fnr</key><value>False</value></param>
<param><key>prepend_string</key><value>""</value></param>
<param><key>print_gsmtap_header</key><value>False</value></param>
</block>
<block>
<key>gsm_receiver</key>
<param><key>id</key><value>gsm_receiver_0</value></param>
<param><key>cell_allocation</key><value>[arfcn.downlink2arfcn(fc)]</value></param>
<param><key>osr</key><value>4</value></param>
</block>
<block>
<key>gsm_sdcch8_demapper</key>
<param><key>id</key><value>gsm_sdcch8_demapper_0</value></param>
<param><key>timeslot_nr</key><value>1</value></param>
</block>
<block>
<key>gsm_tmsi_dumper</key>
<param><key>id</key><value>gsm_tmsi_dumper_0</value></param>
<param><key>filename</key><value>/tmp/tmsicount.txt</value></param>
<param><key>print_message</key><value>True</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import pi</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from grgsm import arfcn</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>osr</value></param>
<param><key>label</key><value>OverSampling Ratio</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>label</key><value>Clock frequency offset in ppms (1/1e6 parts)</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rec_len</value></param>
<param><key>label</key><value>Recording length in seconds</value></param>
<param><key>short_id</key><value>T</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>250e3+abs(shiftoff)</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>corr0</key><value>ppm</value></param>
<param><key>freq0</key><value>fc-shiftoff</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value>args</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2000000.052982</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>serverport</value></param>
<param><key>label</key><value>UDP server listening port</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>4729</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>shiftoff</value></param>
<param><key>label</key><value>Frequency Shiftoff</value></param>
<param><key>short_id</key><value>o</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>400e3</value></param>
</block>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_rotator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>gsm_input_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_0</source_block_id><sink_block_id>gsm_message_printer_1</sink_block_id><source_key>pdus</source_key><sink_key>msgs</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_0</source_block_id><sink_block_id>gsm_tmsi_dumper_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>gsm_bcch_ccch_sdcch4_demapper_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_clock_offset_control_0</source_block_id><sink_block_id>gsm_input_0</sink_block_id><source_key>ctrl</source_key><sink_key>ctrl_in</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0</source_block_id><sink_block_id>blocks_socket_pdu_0_1</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0_0</source_block_id><sink_block_id>blocks_socket_pdu_0_1</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_decryption_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_input_0</source_block_id><sink_block_id>gsm_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_bcch_ccch_sdcch4_demapper_0</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_sdcch8_demapper_0</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_clock_offset_control_0</sink_block_id><source_key>measurements</source_key><sink_key>measurements</sink_key></connection>
<connection><source_block_id>gsm_sdcch8_demapper_0</source_block_id><sink_block_id>gsm_decryption_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
