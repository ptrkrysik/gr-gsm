<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>receiver_rtlsdr</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000.026491</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ppm</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-50</value></param>
<param><key>max</key><value>50</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>940e6</value></param>
<param><key>min</key><value>800e6</value></param>
<param><key>max</key><value>1000e6</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>g</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>43</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>gsm_get_bcch_or_ccch_bursts</key>
<param><key>id</key><value>gsm_get_bcch_or_ccch_bursts_0</value></param>
<param><key>d_fn51_start</key><value>2</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>fc</value></param>
<param><key>corr0</key><value>ppm</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>gain0</key><value>g</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>250e3</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0</value></param>
</block>
<block>
<key>clock_offset_corrector</key>
<param><key>id</key><value>clock_offset_corrector_0</value></param>
<param><key>ppm</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>fc</key><value>fc</value></param>
</block>
<block>
<key>gsm_clock_offset_control</key>
<param><key>id</key><value>gsm_clock_offset_control_0</value></param>
<param><key>fc</key><value>fc</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>gsm_message_printer</key>
<param><key>id</key><value>gsm_message_printer_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>gsm_receiver_hier</key>
<param><key>id</key><value>gsm_receiver_hier_0</value></param>
<param><key>input_rate</key><value>samp_rate</value></param>
<param><key>osr</key><value>4</value></param>
<param><key>arfcn</key><value>0</value></param>
</block>
<connection><source_block_id>gsm_control_channels_decoder_0</source_block_id><sink_block_id>gsm_message_printer_0</sink_block_id><source_key>msgs</source_key><sink_key>msgs</sink_key></connection>
<connection><source_block_id>gsm_clock_offset_control_0</source_block_id><sink_block_id>clock_offset_corrector_0</sink_block_id><source_key>ppm</source_key><sink_key>ppm</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>clock_offset_corrector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>clock_offset_corrector_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>clock_offset_corrector_0</source_block_id><sink_block_id>gsm_receiver_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_receiver_hier_0</source_block_id><sink_block_id>gsm_get_bcch_or_ccch_bursts_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_hier_0</source_block_id><sink_block_id>gsm_clock_offset_control_0</sink_block_id><source_key>measurements</source_key><sink_key>measurements</sink_key></connection>
<connection><source_block_id>gsm_get_bcch_or_ccch_bursts_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_hier_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>measurements</source_key><sink_key>print</sink_key></connection>
</flow_graph>
