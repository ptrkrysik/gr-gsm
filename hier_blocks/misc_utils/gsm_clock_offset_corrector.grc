<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>import</key>
<param><key>id</key><value>math_imp</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_out</value></param>
<param><key>value</key><value>samp_rate_in</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value>fc</value></param>
<param><key>value</key><value>936.6e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>label</key><value>ppm</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_in</value></param>
<param><key>label</key><value>samp_rate_in</value></param>
<param><key>value</key><value>1625000.0/6.0*4.0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_out</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>samp_rate_out</value></param>
<param><key>value</key><value>1625000.0/6.0*4.0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>ppm_in</value></param>
<param><key>label</key><value>ppm_in</value></param>
<param><key>type</key><value>message</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>fractional_resampler_xx</key>
<param><key>id</key><value>fractional_resampler_xx_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>resamp_ratio</key><value>samp_rate_in/samp_rate_out</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>fc/samp_rate_out*(2*math.pi)/1e6</value></param>
</block>
<block>
<key>fractional_resampler_xx</key>
<param><key>id</key><value>fractional_resampler_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>resamp_ratio</key><value>samp_rate_in/samp_rate_out</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1.0e-6*samp_rate_in/samp_rate_out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>gsm_controlled_rotator_cc</key>
<param><key>id</key><value>gsm_controlled_rotator_cc_0</value></param>
<param><key>phase_inc</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate_out</value></param>
</block>
<block>
<key>gsm_controlled_const_source_f</key>
<param><key>id</key><value>gsm_controlled_const_source_f_0</value></param>
<param><key>constant</key><value>ppm</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>samp_rate_in/samp_rate_out</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>clock_offset_corrector</value></param>
<param><key>title</key><value>Clock offset corrector</value></param>
<param><key>author</key><value>Piotr Krysik</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>GSM</value></param>
</block>
<connection><source_block_id>ppm_in</source_block_id><sink_block_id>gsm_controlled_const_source_f_0</sink_block_id><source_key>0</source_key><sink_key>constant_msg</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>fractional_resampler_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>fractional_resampler_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>fractional_resampler_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0</source_block_id><sink_block_id>gsm_controlled_rotator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>fractional_resampler_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0_0</source_block_id><sink_block_id>gsm_controlled_rotator_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>gsm_controlled_rotator_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gsm_controlled_rotator_cc_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_controlled_const_source_f_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_controlled_const_source_f_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
