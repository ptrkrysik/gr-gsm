<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gsm_receiver_usrp_channelizer</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100e6/10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate2</value></param>
<param><key>value</key><value>samp_rate/25</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>length</value></param>
<param><key>value</key><value>30</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>25</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>50</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>gsm_bursts_printer</key>
<param><key>id</key><value>gsm_bursts_printer_0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>957</value></param>
<param><key>min</key><value>800</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>gsm_receiver_hier</key>
<param><key>id</key><value>gsm_receiver_hier_0_0</value></param>
<param><key>input_rate</key><value>samp_rate2</value></param>
<param><key>osr</key><value>4</value></param>
<param><key>arfcn</key><value>0</value></param>
</block>
<block>
<key>pfb_channelizer_ccf</key>
<param><key>id</key><value>pfb_channelizer_ccf_0</value></param>
<param><key>nchans</key><value>25</value></param>
<param><key>osr</key><value>1</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>ch_map</key><value>[]</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>otw</key><value>sc16</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>fc*1e6</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant0</key><value></value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>pfb_channelizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_receiver_hier_0_0</source_block_id><sink_block_id>gsm_bursts_printer_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>gsm_receiver_hier_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
