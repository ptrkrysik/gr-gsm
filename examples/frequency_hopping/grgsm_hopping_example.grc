options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: grgsm_hopping_example
    output_language: python
    run_options: run
  states: {}

blocks:
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./recording9_hopping_downlink_941M_samp_12.5M_20160226/out_51.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: ./recording9_hopping_downlink_941M_samp_12.5M_20160226/out_45.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: ./recording9_hopping_downlink_941M_samp_12.5M_20160226/out_37.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_2
  id: blocks_file_source
  parameters:
    file: ./recording9_hopping_downlink_941M_samp_12.5M_20160226/out_2.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4729'
    type: UDP_CLIENT
  states: {}
- name: blocks_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4729'
    type: UDP_SERVER
  states: {}
- name: fc
  id: parameter
  parameters:
    label: fc
    short_id: f
    type: eng_float
    value: 940e6
  states: {}
- name: gsm_bcch_ccch_demapper_0
  id: gsm_bcch_ccch_demapper
  parameters:
    timeslot_nr: '0'
  states: {state: disabled}
- name: gsm_clock_offset_control_0
  id: gsm_clock_offset_control
  parameters:
    fc: fc
    osr: osr
    samp_rate: samp_rate
  states: {state: disabled}
- name: gsm_control_channels_decoder_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {state: disabled}
- name: gsm_control_channels_decoder_0_0_0_0_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0_0_0_0_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0_0_0_0_1
  id: gsm_control_channels_decoder
  parameters: {}
  states: {state: disabled}
- name: gsm_cx_channel_hopper_0
  id: gsm_cx_channel_hopper
  parameters:
    hsn: '0'
    ma: '[2,37,45]'
    maio: '0'
  states: {}
- name: gsm_cx_channel_hopper_0_0
  id: gsm_cx_channel_hopper
  parameters:
    hsn: '0'
    ma: '[2,37,45]'
    maio: '1'
  states: {state: disabled}
- name: gsm_decryption_0
  id: gsm_decryption
  parameters:
    a5_version: '1'
    k_c: '[0x75, 0x5c, 0x62, 0x2a, 0x56, 0x15, 0xcf, 0x37]'
  states: {}
- name: gsm_decryption_0_0
  id: gsm_decryption
  parameters:
    a5_version: '1'
    k_c: '[0x75, 0x5c, 0x62, 0x2a, 0x56, 0x15, 0xcf, 0x37]'
  states: {state: disabled}
- name: gsm_decryption_0_0_0
  id: gsm_decryption
  parameters:
    a5_version: '1'
    k_c: '[0x75, 0x5c, 0x62, 0x2a, 0x56, 0x15, 0xcf, 0x37]'
  states: {state: disabled}
- name: gsm_input_0
  id: gsm_input
  parameters:
    samp_rate_in: samp_rate
  states: {}
- name: gsm_input_0_0
  id: gsm_input
  parameters:
    samp_rate_in: samp_rate
  states: {}
- name: gsm_input_0_0_0
  id: gsm_input
  parameters:
    samp_rate_in: samp_rate
  states: {}
- name: gsm_input_0_0_0_0
  id: gsm_input
  parameters:
    samp_rate_in: samp_rate
  states: {}
- name: gsm_message_printer_0
  id: gsm_message_printer
  parameters:
    prepend_fnr: 'False'
    prepend_frame_count: 'False'
    prepend_string: '""'
    print_gsmtap_header: 'False'
  states: {}
- name: gsm_receiver_0
  id: gsm_receiver
  parameters:
    cell_allocation: '[51,2,37,45]'
    num_streams: '4'
    osr: osr
    tseq_nums: '[4]'
  states: {}
- name: gsm_sdcch8_demapper_0
  id: gsm_sdcch8_demapper
  parameters:
    timeslot_nr: '0'
  states: {}
- name: gsm_tch_f_chans_demapper_0
  id: gsm_tch_f_chans_demapper
  parameters:
    timeslot_nr: '5'
  states: {state: disabled}
- name: gsm_tch_f_decoder_0
  id: gsm_tch_f_decoder
  parameters:
    boundary_check: 'True'
    mode: gsm.TCH_FS
  states: {state: disabled}
- name: osr
  id: parameter
  parameters:
    label: OSR
    type: intx
    value: '4'
  states: {}
- name: ppm
  id: parameter
  parameters:
    label: clock_correction
    short_id: p
    type: eng_float
    value: '-0.5'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    short_id: s
    type: eng_float
    value: 0.5e6
  states: {}

connections:
- [blocks_file_source_0, '0', gsm_input_0, '0']
- [blocks_file_source_0, '0', qtgui_sink_x_0, '0']
- [blocks_file_source_0_0, '0', gsm_input_0_0_0_0, '0']
- [blocks_file_source_0_1, '0', gsm_input_0_0_0, '0']
- [blocks_file_source_0_2, '0', gsm_input_0_0, '0']
- [gsm_bcch_ccch_demapper_0, bursts, gsm_control_channels_decoder_0, bursts]
- [gsm_clock_offset_control_0, ctrl, gsm_input_0, ctrl_in]
- [gsm_clock_offset_control_0, ctrl, gsm_input_0_0, ctrl_in]
- [gsm_clock_offset_control_0, ctrl, gsm_input_0_0_0, ctrl_in]
- [gsm_clock_offset_control_0, ctrl, gsm_input_0_0_0_0, ctrl_in]
- [gsm_control_channels_decoder_0, msgs, blocks_socket_pdu_0, pdus]
- [gsm_control_channels_decoder_0_0_0_0_0, msgs, blocks_socket_pdu_0, pdus]
- [gsm_control_channels_decoder_0_0_0_0_0, msgs, gsm_message_printer_0, msgs]
- [gsm_control_channels_decoder_0_0_0_0_0_0, msgs, blocks_socket_pdu_0, pdus]
- [gsm_control_channels_decoder_0_0_0_0_0_0, msgs, gsm_message_printer_0, msgs]
- [gsm_control_channels_decoder_0_0_0_0_0_1, msgs, blocks_socket_pdu_0, pdus]
- [gsm_control_channels_decoder_0_0_0_0_0_1, msgs, gsm_message_printer_0, msgs]
- [gsm_cx_channel_hopper_0, bursts, gsm_sdcch8_demapper_0, bursts]
- [gsm_cx_channel_hopper_0_0, bursts, gsm_tch_f_chans_demapper_0, bursts]
- [gsm_decryption_0, bursts, gsm_control_channels_decoder_0_0_0_0_0, bursts]
- [gsm_decryption_0_0, bursts, gsm_control_channels_decoder_0_0_0_0_0_1, bursts]
- [gsm_decryption_0_0_0, bursts, gsm_tch_f_decoder_0, bursts]
- [gsm_input_0, '0', gsm_receiver_0, '0']
- [gsm_input_0_0, '0', gsm_receiver_0, '1']
- [gsm_input_0_0_0, '0', gsm_receiver_0, '2']
- [gsm_input_0_0_0_0, '0', gsm_receiver_0, '3']
- [gsm_receiver_0, C0, gsm_bcch_ccch_demapper_0, bursts]
- [gsm_receiver_0, CX, gsm_cx_channel_hopper_0, CX]
- [gsm_receiver_0, CX, gsm_cx_channel_hopper_0_0, CX]
- [gsm_receiver_0, measurements, gsm_clock_offset_control_0, measurements]
- [gsm_sdcch8_demapper_0, bursts, gsm_control_channels_decoder_0_0_0_0_0_0, bursts]
- [gsm_sdcch8_demapper_0, bursts, gsm_decryption_0, bursts]
- [gsm_tch_f_chans_demapper_0, acch_bursts, gsm_decryption_0_0, bursts]
- [gsm_tch_f_chans_demapper_0, tch_bursts, gsm_decryption_0_0_0, bursts]
- [gsm_tch_f_decoder_0, msgs, blocks_socket_pdu_0, pdus]
- [gsm_tch_f_decoder_0, msgs, gsm_message_printer_0, msgs]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
