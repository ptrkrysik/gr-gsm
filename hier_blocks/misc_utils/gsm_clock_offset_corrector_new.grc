<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>clock_offset_corrector_new</value></param>
<param><key>author</key><value>Piotr Krysik</value></param>
<param><key>category</key><value>GSM</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Clock offset corrector</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_out</value></param>
<param><key>value</key><value>samp_rate_in</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>ctrl_in</value></param>
<param><key>label</key><value>ctrl_in</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value>fc</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>936.6e6</value></param>
</block>
<block>
<key>grgsm_msg_to_tag</key>
<param><key>id</key><value>grgsm_msg_to_tag_0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>math_imp</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>label</key><value>ppm</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_in</value></param>
<param><key>label</key><value>samp_rate_in</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1625000.0/6.0*4.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_out</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>samp_rate_out</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1625000.0/6.0*4.0</value></param>
</block>
<connection><source_block_id>ctrl_in</source_block_id><sink_block_id>grgsm_msg_to_tag_0</sink_block_id><source_key>out</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>grgsm_msg_to_tag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
